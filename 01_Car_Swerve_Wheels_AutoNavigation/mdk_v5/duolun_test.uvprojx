# Keil uVision project duolun_test.uvprojx, settings and files
target template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: C:\Users\Abyss9\Desktop\AT32资料\libraries\drivers\inc;C:\Users\Abyss9\Desktop\AT32资料\libraries\cmsis\cm4\core_support;C:\Users\Abyss9\Desktop\AT32资料\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c main.c can.c motor.c pid.c chassis.c remote.c hwt9018.c path_planner.c odometry.c navigation.c
  group bsp
    ../src/: at32f403a_407_board.c
  group firmware
    C:/Users/Abyss9/Desktop/AT32资料/libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group cmsis
    C:/Users/Abyss9/Desktop/AT32资料/libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    C:/Users/Abyss9/Desktop/AT32资料/libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
